
OPTEEMACHINE:ls1028amyd = "ls-ls1028ardb"

